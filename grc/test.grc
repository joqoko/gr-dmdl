<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>SIFS</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Single_rxp_time_s</value></param>
<param><key>value</key><value>60</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cs_threshold</value></param>
<param><key>value</key><value>0.001</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>destination_address</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>diff_preamble_128</value></param>
<param><key>value</key><value>[1, 1, 1, 1, 1, 1, 1, 1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 1, 0, 1, 1, 0, 1, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 1, 1, 1, 0, 1, 0, 0, 1, 1, 0, 1, 1, 1, 1, 0, 1, 0, 1, 1, 1, 0, 1, 1, 0, 1, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1, 0,0, 1, 1, 0, 1, 0, 0, 0, 1, 0, 1, 1, 1, 0, 0, 0, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 1, 1, 1, 1, 1, 1, 0, 1, 1, 1, 1, 1, 0, 1, 0,0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 1, 1, 1, 1, 0, 1, 1, 0, 0, 0, 1, 0, 1, 0, 0, 1, 1, 1, 0, 0, 0, 0, 1, 1, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 1, 0, 0, 0, 1, 1, 0, 0, 0, 1, 1, 0, 1, 1, 0, 0, 1, 0, 1, 0, 1, 1, 1, 1, 0, 0, 1, 0, 0, 0, 1, 1, 1, 1, 1, 0, 0, 1,1, 1, 1, 0, 0, 0, 1, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 1, 0, 1, 1, 1, 0, 0, 1, 0, 1, 1, 0, 0, 0, 0, 1, 0, 1, 1, 0, 1, 1, 1, 0, 1, 0, 1, 0, 0, 1, 0, 0][0:128]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>min_window_size</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mu</value></param>
<param><key>value</key><value>0.6</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>rrc</value></param>
<param><key>alpha</key><value>0.5</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>ntaps</key><value>11*sps</value></param>
<param><key>samp_rate</key><value>sps</value></param>
<param><key>sym_rate</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_center_frequency</value></param>
<param><key>value</key><value>3.9e8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>25</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>400000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>slot_time</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>source_address</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>system_time_granularity_us</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>timeout_duration_ms</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_center_frequency</value></param>
<param><key>value</key><value>3.9e8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_device_address</value></param>
<param><key>value</key><value>"addr=192.168.10.2"</value></param>
</block>
<block>
<key>dmdl_attribute_editor</key>
<param><key>id</key><value>dmdl_attribute_editor_0</value></param>
<param><key>field_name</key><value>"frame_index"</value></param>
<param><key>block_id</key><value>16</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>show_reset</key><value>1</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>dmdl_attribute_filter</key>
<param><key>id</key><value>dmdl_attribute_filter_0</value></param>
<param><key>field_name</key><value>"frame_index"</value></param>
<param><key>block_id</key><value>16</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>show_reset</key><value>1</value></param>
<param><key>show_fail</key><value>1</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>dmdl_attribute_splitter</key>
<param><key>id</key><value>dmdl_attribute_splitter_0</value></param>
<param><key>command_name</key><value>"frame_index"</value></param>
<param><key>block_id</key><value>16</value></param>
<param><key>develop_mode</key><value>0</value></param>
</block>
<block>
<key>dmdl_counter</key>
<param><key>id</key><value>dmdl_counter_0</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>counter_id</key><value>100</value></param>
<param><key>interval_mode</key><value>1</value></param>
<param><key>counter_name</key><value>""</value></param>
<param><key>record_on</key><value>0</value></param>
<param><key>record_path</key><value>"/home/pwa/Source/gr-dmdl/result"</value></param>
<param><key>reset</key><value>1</value></param>
<param><key>name_with_timestamp</key><value>1</value></param>
</block>
<block>
<key>dmdl_cts_framing</key>
<param><key>id</key><value>dmdl_cts_framing_0</value></param>
<param><key>block_id</key><value>31</value></param>
<param><key>default_ifs_setting</key><value>default</value></param>
<param><key>default_PHY_setting</key><value>default</value></param>
<param><key>default_framing_setting</key><value>default</value></param>
<param><key>destination_address</key><value>destination_address</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>len_rts_cts_payload</key><value>3</value></param>
<param><key>len_destination_address</key><value>1</value></param>
<param><key>len_frame_index</key><value>1</value></param>
<param><key>len_frame_type</key><value>1</value></param>
<param><key>len_num_transmission</key><value>1</value></param>
<param><key>len_payload_length</key><value>2</value></param>
<param><key>len_reserved_field_I</key><value>2</value></param>
<param><key>len_reserved_field_II</key><value>2</value></param>
<param><key>len_source_address</key><value>1</value></param>
<param><key>output_frame_pmt</key><value>1</value></param>
<param><key>padding</key><value>64</value></param>
<param><key>preamble</key><value>diff_preamble_128</value></param>
<param><key>reserved_field_I</key><value>318</value></param>
<param><key>reserved_field_II</key><value>524</value></param>
<param><key>SIFS</key><value>1000</value></param>
<param><key>set_reserved_field</key><value>1</value></param>
<param><key>slot_time</key><value>800</value></param>
<param><key>source_address</key><value>source_address</value></param>
<param><key>bps</key><value>gnuradio.digital.constellation_qpsk().bits_per_symbol() * (samp_rate / sps)</value></param>
</block>
<block>
<key>dmdl_dummy_source</key>
<param><key>id</key><value>dmdl_dummy_source_0</value></param>
<param><key>block_id</key><value>23</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>packet_rate</key><value>1</value></param>
<param><key>payload_length</key><value>100</value></param>
<param><key>show</key><value>1</value></param>
<param><key>source_type</key><value>1</value></param>
</block>
<block>
<key>dmdl_framing</key>
<param><key>id</key><value>dmdl_framing_0</value></param>
<param><key>block_id</key><value>17</value></param>
<param><key>default_framing_setting</key><value>default</value></param>
<param><key>default_payload_length</key><value>300</value></param>
<param><key>destination_address</key><value>destination_address</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>frame_type</key><value>1</value></param>
<param><key>increase_index</key><value>1</value></param>
<param><key>frame_index</key><value>1</value></param>
<param><key>len_destination_address</key><value>1</value></param>
<param><key>len_frame_index</key><value>1</value></param>
<param><key>len_frame_type</key><value>1</value></param>
<param><key>len_num_transmission</key><value>1</value></param>
<param><key>len_payload_length</key><value>2</value></param>
<param><key>len_reserved_field_I</key><value>2</value></param>
<param><key>len_reserved_field_II</key><value>2</value></param>
<param><key>len_slot_time_beacon</key><value>2</value></param>
<param><key>len_source_address</key><value>1</value></param>
<param><key>node_list</key><value>[2, 3]</value></param>
<param><key>output_frame_pmt</key><value>1</value></param>
<param><key>reserved_field_I</key><value>318</value></param>
<param><key>reserved_field_II</key><value>524</value></param>
<param><key>reserved_field_ampdu</key><value>0</value></param>
<param><key>set_reserved_field</key><value>1</value></param>
<param><key>show_reset_index</key><value>1</value></param>
<param><key>show_reset_initial_index</key><value>1</value></param>
<param><key>slot_list_ms</key><value>[1000, 1000]</value></param>
<param><key>source_address</key><value>source_address</value></param>
<param><key>default_payload</key><value>0</value></param>
<param><key>internal_index</key><value>1</value></param>
</block>
<block>
<key>dmdl_rts_framing</key>
<param><key>id</key><value>dmdl_rts_framing_0</value></param>
<param><key>block_id</key><value>30</value></param>
<param><key>default_ifs_setting</key><value>default</value></param>
<param><key>default_PHY_setting</key><value>default</value></param>
<param><key>default_framing_setting</key><value>default</value></param>
<param><key>destination_address</key><value>destination_address</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>len_rts_cts_payload</key><value>3</value></param>
<param><key>len_destination_address</key><value>1</value></param>
<param><key>len_frame_index</key><value>1</value></param>
<param><key>len_frame_type</key><value>1</value></param>
<param><key>len_num_transmission</key><value>1</value></param>
<param><key>len_payload_length</key><value>2</value></param>
<param><key>len_reserved_field_I</key><value>2</value></param>
<param><key>len_reserved_field_II</key><value>2</value></param>
<param><key>len_source_address</key><value>1</value></param>
<param><key>output_frame_pmt</key><value>1</value></param>
<param><key>padding</key><value>64</value></param>
<param><key>preamble</key><value>diff_preamble_128</value></param>
<param><key>reserved_field_I</key><value>318</value></param>
<param><key>reserved_field_II</key><value>524</value></param>
<param><key>SIFS</key><value>1000</value></param>
<param><key>set_reserved_field</key><value>1</value></param>
<param><key>slot_time</key><value>800</value></param>
<param><key>source_address</key><value>source_address</value></param>
<param><key>bps</key><value>gnuradio.digital.constellation_qpsk().bits_per_symbol() * (samp_rate / sps)</value></param>
</block>
<block>
<key>dmdl_start</key>
<param><key>id</key><value>dmdl_start_0</value></param>
<param><key>start_next_time_s</key><value>5</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
</block>
<block>
<key>dmdl_timer</key>
<param><key>id</key><value>dmdl_timer_0</value></param>
<param><key>block_id</key><value>5</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>duration_ms</key><value>500</value></param>
<param><key>address_check</key><value>1</value></param>
<param><key>disable_timer</key><value>1</value></param>
<param><key>resume_timer</key><value>1</value></param>
<param><key>suspend_timer</key><value>1</value></param>
<param><key>reserved_time_ms</key><value>0</value></param>
<param><key>reset_duration</key><value>1</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
<param><key>timer_type</key><value>0</value></param>
</block>
<block>
<key>dmdl_timer</key>
<param><key>id</key><value>dmdl_timer_1</value></param>
<param><key>block_id</key><value>5</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>duration_ms</key><value>1000</value></param>
<param><key>address_check</key><value>1</value></param>
<param><key>disable_timer</key><value>1</value></param>
<param><key>resume_timer</key><value>1</value></param>
<param><key>suspend_timer</key><value>1</value></param>
<param><key>reserved_time_ms</key><value>0</value></param>
<param><key>reset_duration</key><value>1</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
<param><key>timer_type</key><value>0</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import gnuradio</value></param>
</block>
<block>
<key>inets_frame_probe</key>
<param><key>id</key><value>inets_frame_probe_0</value></param>
<param><key>block_id</key><value>100</value></param>
<param><key>cs_threshold</key><value>0.01</value></param>
<param><key>cs_mode</key><value>0</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>enable_new_name</key><value>1</value></param>
<param><key>file_name_extension</key><value>""</value></param>
<param><key>output_time_info</key><value>1</value></param>
<param><key>print_frame</key><value>0</value></param>
<param><key>record_on</key><value>0</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>name_with_stamp</key><value>1</value></param>
</block>
<connection><source_block_id>dmdl_attribute_editor_0</source_block_id><sink_block_id>dmdl_attribute_filter_0</sink_block_id><source_key>End</source_key><sink_key>Begin</sink_key></connection>
<connection><source_block_id>dmdl_cts_framing_0</source_block_id><sink_block_id>dmdl_rts_framing_0</sink_block_id><source_key>frame_out</source_key><sink_key>cts_frame_in</sink_key></connection>
<connection><source_block_id>dmdl_dummy_source_0</source_block_id><sink_block_id>dmdl_framing_0</sink_block_id><source_key>End</source_key><sink_key>Begin</sink_key></connection>
<connection><source_block_id>dmdl_framing_0</source_block_id><sink_block_id>dmdl_rts_framing_0</sink_block_id><source_key>End</source_key><sink_key>data_frame_in</sink_key></connection>
<connection><source_block_id>dmdl_rts_framing_0</source_block_id><sink_block_id>dmdl_cts_framing_0</sink_block_id><source_key>frame_out</source_key><sink_key>rts_frame_info_in</sink_key></connection>
<connection><source_block_id>dmdl_rts_framing_0</source_block_id><sink_block_id>inets_frame_probe_0</sink_block_id><source_key>frame_out</source_key><sink_key>info_in</sink_key></connection>
<connection><source_block_id>dmdl_start_0</source_block_id><sink_block_id>dmdl_timer_0</sink_block_id><source_key>Begin</source_key><sink_key>Begin</sink_key></connection>
<connection><source_block_id>dmdl_timer_0</source_block_id><sink_block_id>dmdl_dummy_source_0</sink_block_id><source_key>End</source_key><sink_key>Begin</sink_key></connection>
</flow_graph>

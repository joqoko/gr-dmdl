<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>dmdl_framing</key>
<param><key>id</key><value>dmdl_framing_0</value></param>
<param><key>block_id</key><value>17</value></param>
<param><key>default_framing_setting</key><value>default</value></param>
<param><key>default_payload_length</key><value>300</value></param>
<param><key>destination_address</key><value>1</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>frame_type</key><value>1</value></param>
<param><key>increase_index</key><value>1</value></param>
<param><key>frame_index</key><value>0</value></param>
<param><key>len_destination_address</key><value>1</value></param>
<param><key>len_frame_index</key><value>1</value></param>
<param><key>len_frame_type</key><value>1</value></param>
<param><key>len_num_transmission</key><value>1</value></param>
<param><key>len_payload_length</key><value>2</value></param>
<param><key>len_reserved_field_I</key><value>2</value></param>
<param><key>len_reserved_field_II</key><value>2</value></param>
<param><key>len_slot_time_beacon</key><value>2</value></param>
<param><key>len_source_address</key><value>1</value></param>
<param><key>node_list</key><value>[2, 3]</value></param>
<param><key>output_frame_pmt</key><value>1</value></param>
<param><key>reserved_field_I</key><value>318</value></param>
<param><key>reserved_field_II</key><value>524</value></param>
<param><key>reserved_field_ampdu</key><value>0</value></param>
<param><key>set_reserved_field</key><value>1</value></param>
<param><key>show_reset_index</key><value>1</value></param>
<param><key>show_reset_initial_index</key><value>1</value></param>
<param><key>slot_list_ms</key><value>[1000, 1000]</value></param>
<param><key>source_address</key><value>2</value></param>
<param><key>default_payload</key><value>0</value></param>
<param><key>internal_index</key><value>1</value></param>
</block>
<block>
<key>dmdl_redundancy_remover</key>
<param><key>id</key><value>dmdl_redundancy_remover_0</value></param>
<param><key>block_id</key><value>49</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>output_re</key><value>1</value></param>
</block>
<block>
<key>dmdl_replicate</key>
<param><key>id</key><value>dmdl_replicate_0</value></param>
<param><key>block_id</key><value>37</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>show_complete</key><value>1</value></param>
<param><key>replicate_number</key><value>4</value></param>
<param><key>reset_number_replicate</key><value>1</value></param>
</block>
<block>
<key>inets_dummy_source</key>
<param><key>id</key><value>inets_dummy_source_0</value></param>
<param><key>block_id</key><value>23</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>packet_rate</key><value>1</value></param>
<param><key>payload_length</key><value>100</value></param>
<param><key>show</key><value>1</value></param>
<param><key>source_type</key><value>1</value></param>
</block>
<block>
<key>inets_frame_probe</key>
<param><key>id</key><value>inets_frame_probe_0</value></param>
<param><key>block_id</key><value>1</value></param>
<param><key>cs_threshold</key><value>0.01</value></param>
<param><key>cs_mode</key><value>0</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>enable_new_name</key><value>1</value></param>
<param><key>file_name_extension</key><value>""</value></param>
<param><key>output_time_info</key><value>1</value></param>
<param><key>print_frame</key><value>0</value></param>
<param><key>record_on</key><value>0</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>name_with_stamp</key><value>1</value></param>
</block>
<block>
<key>inets_frame_probe</key>
<param><key>id</key><value>inets_frame_probe_0_0</value></param>
<param><key>block_id</key><value>2</value></param>
<param><key>cs_threshold</key><value>0.01</value></param>
<param><key>cs_mode</key><value>0</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>enable_new_name</key><value>1</value></param>
<param><key>file_name_extension</key><value>""</value></param>
<param><key>output_time_info</key><value>1</value></param>
<param><key>print_frame</key><value>0</value></param>
<param><key>record_on</key><value>0</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>name_with_stamp</key><value>1</value></param>
</block>
<block>
<key>inets_frame_probe</key>
<param><key>id</key><value>inets_frame_probe_0_0_0</value></param>
<param><key>block_id</key><value>3</value></param>
<param><key>cs_threshold</key><value>0.01</value></param>
<param><key>cs_mode</key><value>0</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>enable_new_name</key><value>1</value></param>
<param><key>file_name_extension</key><value>""</value></param>
<param><key>output_time_info</key><value>1</value></param>
<param><key>print_frame</key><value>0</value></param>
<param><key>record_on</key><value>0</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>name_with_stamp</key><value>1</value></param>
</block>
<block>
<key>inets_run</key>
<param><key>id</key><value>inets_run_0</value></param>
<param><key>start_next_time_s</key><value>5</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
</block>
<connection><source_block_id>dmdl_framing_0</source_block_id><sink_block_id>dmdl_replicate_0</sink_block_id><source_key>End</source_key><sink_key>Begin</sink_key></connection>
<connection><source_block_id>dmdl_replicate_0</source_block_id><sink_block_id>dmdl_redundancy_remover_0</sink_block_id><source_key>End</source_key><sink_key>Begin</sink_key></connection>
<connection><source_block_id>inets_dummy_source_0</source_block_id><sink_block_id>dmdl_framing_0</sink_block_id><source_key>output</source_key><sink_key>Begin</sink_key></connection>
<connection><source_block_id>inets_run_0</source_block_id><sink_block_id>inets_dummy_source_0</sink_block_id><source_key>trigger_out</source_key><sink_key>trigger</sink_key></connection>
</flow_graph>

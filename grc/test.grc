<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>dmdl_address_check</key>
<param><key>id</key><value>dmdl_address_check_0</value></param>
<param><key>my_address</key><value>source_address</value></param>
<param><key>block_id</key><value>17</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>output_payload_pmt</key><value>1</value></param>
<param><key>show_not_pass</key><value>0</value></param>
<param><key>mode</key><value>0</value></param>
</block>
<block>
<key>dmdl_error_detection</key>
<param><key>id</key><value>dmdl_error_detection_0</value></param>
<param><key>block_id</key><value>9</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>output_bad_frame</key><value>1</value></param>
<param><key>output_payload_pmt</key><value>1</value></param>
</block>
<block>
<key>dmdl_resend_check</key>
<param><key>id</key><value>dmdl_resend_check_0</value></param>
<param><key>block_id</key><value>24</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>max_resend</key><value>6</value></param>
</block>
<block>
<key>dmdl_timer</key>
<param><key>id</key><value>dmdl_timer_0</value></param>
<param><key>block_id</key><value>5</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>duration_ms</key><value>1000</value></param>
<param><key>address_check</key><value>1</value></param>
<param><key>disable_timer</key><value>1</value></param>
<param><key>resume_timer</key><value>1</value></param>
<param><key>suspend_timer</key><value>1</value></param>
<param><key>reserved_time_ms</key><value>0</value></param>
<param><key>reset_duration</key><value>1</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
<param><key>timer_type</key><value>0</value></param>
</block>
<block>
<key>dmdl_type_check</key>
<param><key>id</key><value>dmdl_type_check_0</value></param>
<param><key>ack_frame</key><value>0</value></param>
<param><key>ampdu_frame</key><value>1</value></param>
<param><key>ampdu_subframe</key><value>1</value></param>
<param><key>amsdu_frame</key><value>1</value></param>
<param><key>amsdu_subframe</key><value>1</value></param>
<param><key>beacon_frame</key><value>1</value></param>
<param><key>block_id</key><value>25</value></param>
<param><key>cts_frame</key><value>1</value></param>
<param><key>data_frame</key><value>0</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>other_frame</key><value>1</value></param>
<param><key>rts_frame</key><value>1</value></param>
</block>
<block>
<key>inets_dummy_source</key>
<param><key>id</key><value>inets_dummy_source_0</value></param>
<param><key>block_id</key><value>23</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>packet_rate</key><value>1</value></param>
<param><key>payload_length</key><value>100</value></param>
<param><key>show</key><value>1</value></param>
<param><key>source_type</key><value>1</value></param>
</block>
<block>
<key>inets_frame_probe</key>
<param><key>id</key><value>inets_frame_probe_0</value></param>
<param><key>block_id</key><value>100</value></param>
<param><key>cs_threshold</key><value>0.01</value></param>
<param><key>cs_mode</key><value>0</value></param>
<param><key>develop_mode</key><value>2</value></param>
<param><key>enable_new_name</key><value>1</value></param>
<param><key>file_name_extension</key><value>""</value></param>
<param><key>output_time_info</key><value>1</value></param>
<param><key>print_frame</key><value>0</value></param>
<param><key>record_on</key><value>0</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>name_with_stamp</key><value>1</value></param>
</block>
<block>
<key>inets_frame_probe</key>
<param><key>id</key><value>inets_frame_probe_0_0</value></param>
<param><key>block_id</key><value>101</value></param>
<param><key>cs_threshold</key><value>0.01</value></param>
<param><key>cs_mode</key><value>0</value></param>
<param><key>develop_mode</key><value>2</value></param>
<param><key>enable_new_name</key><value>1</value></param>
<param><key>file_name_extension</key><value>""</value></param>
<param><key>output_time_info</key><value>1</value></param>
<param><key>print_frame</key><value>0</value></param>
<param><key>record_on</key><value>0</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>name_with_stamp</key><value>1</value></param>
</block>
<block>
<key>inets_resend_check</key>
<param><key>id</key><value>inets_resend_check_0</value></param>
<param><key>block_id</key><value>24</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>max_resend</key><value>6</value></param>
</block>
<block>
<key>inets_run</key>
<param><key>id</key><value>inets_run_0</value></param>
<param><key>start_next_time_s</key><value>5</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
</block>
<connection><source_block_id>dmdl_timer_0</source_block_id><sink_block_id>inets_frame_probe_0_0</sink_block_id><source_key>End</source_key><sink_key>info_in</sink_key></connection>
<connection><source_block_id>inets_dummy_source_0</source_block_id><sink_block_id>dmdl_timer_0</sink_block_id><source_key>output</source_key><sink_key>Begin</sink_key></connection>
<connection><source_block_id>inets_dummy_source_0</source_block_id><sink_block_id>inets_frame_probe_0</sink_block_id><source_key>output</source_key><sink_key>info_in</sink_key></connection>
<connection><source_block_id>inets_run_0</source_block_id><sink_block_id>inets_dummy_source_0</sink_block_id><source_key>trigger_out</source_key><sink_key>trigger</sink_key></connection>
</flow_graph>

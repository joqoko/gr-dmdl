<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>simple_receiver</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>cs_threshold</value></param>
<param><key>value</key><value>0.005</value></param>
<param><key>gui_hint</key><value>tabs@2</value></param>
<param><key>label</key><value>Carrier Sensing Threshold</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>destination_address</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>tabs@0</value></param>
<param><key>label</key><value>Destination address</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>diff_preamble_128</value></param>
<param><key>value</key><value>[1, 1, 1, 1, 1, 1, 1, 1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 1, 0, 1, 1, 0, 1, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 1, 1, 1, 0, 1, 0, 0, 1, 1, 0, 1, 1, 1, 1, 0, 1, 0, 1, 1, 1, 0, 1, 1, 0, 1, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1, 0,0, 1, 1, 0, 1, 0, 0, 0, 1, 0, 1, 1, 1, 0, 0, 0, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 1, 1, 1, 1, 1, 1, 0, 1, 1, 1, 1, 1, 0, 1, 0,0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 1, 1, 1, 1, 0, 1, 1, 0, 0, 0, 1, 0, 1, 0, 0, 1, 1, 1, 0, 0, 0, 0, 1, 1, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 1, 0, 0, 0, 1, 1, 0, 0, 0, 1, 1, 0, 1, 1, 0, 0, 1, 0, 1, 0, 1, 1, 1, 1, 0, 0, 1, 0, 0, 0, 1, 1, 1, 1, 1, 0, 0, 1,1, 1, 1, 0, 0, 0, 1, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 1, 0, 1, 1, 1, 0, 0, 1, 0, 1, 1, 0, 0, 0, 0, 1, 0, 1, 1, 0, 1, 1, 1, 0, 1, 0, 1, 0, 0, 1, 0, 0][0:128]</value></param>
<param><key>gui_hint</key><value>tabs@2</value></param>
<param><key>label</key><value>Preamble 128</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>initial_frame_index</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>tabs@1</value></param>
<param><key>label</key><value>Initial frame index</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mu</value></param>
<param><key>value</key><value>range_mu</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>preamble_detector_threshold</value></param>
<param><key>value</key><value>30</value></param>
<param><key>gui_hint</key><value>tabs@2</value></param>
<param><key>label</key><value>Preamble Detector Threshold</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>range_mu</value></param>
<param><key>value</key><value>0.6</value></param>
<param><key>gui_hint</key><value>tabs@2</value></param>
<param><key>label</key><value>BB Derotation Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>range_rx_gain</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>tabs@2</value></param>
<param><key>label</key><value>Rx Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>25</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>range_tx_gain</value></param>
<param><key>value</key><value>15</value></param>
<param><key>gui_hint</key><value>tabs@2</value></param>
<param><key>label</key><value>Tx Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>25</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>rrc</value></param>
<param><key>alpha</key><value>0.5</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>ntaps</key><value>11*sps</value></param>
<param><key>samp_rate</key><value>sps</value></param>
<param><key>sym_rate</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>rx_center_frequency</value></param>
<param><key>value</key><value>400000000</value></param>
<param><key>gui_hint</key><value>tabs@2</value></param>
<param><key>label</key><value>RX center frequency [Hz]</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>range_rx_gain</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1000000</value></param>
<param><key>gui_hint</key><value>tabs@2</value></param>
<param><key>label</key><value>Sampling rate</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>source_address</value></param>
<param><key>value</key><value>2</value></param>
<param><key>gui_hint</key><value>tabs@0</value></param>
<param><key>label</key><value>Node address</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
<param><key>gui_hint</key><value>tabs@2</value></param>
<param><key>label</key><value>Sample per Symbol</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>tx_center_frequency</value></param>
<param><key>value</key><value>400000000</value></param>
<param><key>gui_hint</key><value>tabs@2</value></param>
<param><key>label</key><value>TX center frequency [Hz]</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>value</key><value>range_tx_gain</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>usrp_device_address</value></param>
<param><key>value</key><value>"addr=192.168.10.2"</value></param>
<param><key>gui_hint</key><value>tabs@0</value></param>
<param><key>label</key><value>USRP address</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>dmdl_frame_analysis</key>
<param><key>id</key><value>dmdl_frame_analysis_0</value></param>
<param><key>apply_self_address_check</key><value>1</value></param>
<param><key>block_id</key><value>7</value></param>
<param><key>default_framing_setting</key><value>default</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>len_destination_address</key><value>1</value></param>
<param><key>len_frame_index</key><value>1</value></param>
<param><key>len_frame_type</key><value>1</value></param>
<param><key>len_num_transmission</key><value>1</value></param>
<param><key>len_payload_length</key><value>2</value></param>
<param><key>len_reserved_field_I</key><value>2</value></param>
<param><key>len_reserved_field_II</key><value>2</value></param>
<param><key>len_source_address</key><value>1</value></param>
<param><key>my_address</key><value>source_address</value></param>
</block>
<block>
<key>dmdl_probe</key>
<param><key>id</key><value>dmdl_probe_0_0_0</value></param>
<param><key>block_id</key><value>100</value></param>
<param><key>cs_threshold</key><value>0.01</value></param>
<param><key>cs_mode</key><value>0</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>enable_new_name</key><value>1</value></param>
<param><key>file_name_extension</key><value>"t2RXe"</value></param>
<param><key>output_time_info</key><value>1</value></param>
<param><key>print_frame</key><value>0</value></param>
<param><key>record_on</key><value>1</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>name_with_timestamp</key><value>1</value></param>
</block>
<block>
<key>dmdl_receiving</key>
<param><key>id</key><value>dmdl_receiving_0</value></param>
<param><key>block_id</key><value>21</value></param>
<param><key>center_frequency</key><value>rx_center_frequency</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>reset_rf</key><value>0</value></param>
<param><key>reset</key><value>1</value></param>
<param><key>mu</key><value>mu</value></param>
<param><key>output_rss</key><value>0</value></param>
<param><key>output_rx_switch</key><value>0</value></param>
<param><key>output_snr</key><value>1</value></param>
<param><key>output_rx_frame</key><value>0</value></param>
<param><key>rx_gain</key><value>rx_gain</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>threshold</key><value>30</value></param>
<param><key>constellation</key><value>gnuradio.digital.constellation_qpsk().base()</value></param>
<param><key>matched_filter_coeff</key><value>rrc</value></param>
<param><key>preamble</key><value>diff_preamble_128</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>usrp_device_address</key><value>usrp_device_address</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import gnuradio</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tabs</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label0</key><value>General</value></param>
<param><key>label1</key><value>MAC</value></param>
<param><key>label2</key><value>PHY and Radio</value></param>
<param><key>label3</key><value>System</value></param>
<param><key>num_tabs</key><value>4</value></param>
</block>
<connection><source_block_id>dmdl_frame_analysis_0</source_block_id><sink_block_id>dmdl_probe_0_0_0</sink_block_id><source_key>P</source_key><sink_key>B</sink_key></connection>
<connection><source_block_id>dmdl_receiving_0</source_block_id><sink_block_id>dmdl_frame_analysis_0</sink_block_id><source_key>E</source_key><sink_key>B</sink_key></connection>
</flow_graph>
